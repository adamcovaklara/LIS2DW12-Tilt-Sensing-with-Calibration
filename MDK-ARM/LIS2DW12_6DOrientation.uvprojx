# Keil uVision project LIS2DW12_6DOrientation.uvprojx, settings and files
target LIS2DW12_6DOrientation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x20017FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: TiltSensing +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=TiltSensing.bin TiltSensing.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,
  c include: ../Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/lsm6dso/;../../../../../../Drivers/BSP/Components/lis2dw12/;../../../../../../Drivers/BSP/Components/lis2mdl/;../../../../../../Drivers/BSP/Components/hts221/;../../../../../../Drivers/BSP/Components/lps22hh/;../../../../../../Drivers/BSP/Components/stts751/;../../../../../../Drivers/BSP/IKS01A3/;../../../../../../Drivers/BSP/Components/Common/
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_nucleo_bus.c stm32l4xx_nucleo.c serial_protocol.c stm32l4xx_it.c stm32l4xx_hal_msp.c app_mems_int_pin_a_interface.c MotionTL_Manager.c
    ../Inc/: motion_tl.h MotionTL_Manager.h serial.h serial_protocol.h
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso_reg.c lsm6dso.c
    ../../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12_reg.c lis2dw12.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c hts221.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c lps22hh.c
    ../../../../../../Drivers/BSP/Components/stts751/: stts751_reg.c stts751.c
  group Drivers/BSP/IKS01A3
    ../../../../../../Drivers/BSP/IKS01A3/: iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c iks01a3_env_sensors.c iks01a3_env_sensors_ex.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/: stm32l4xx_hal_rtc.h
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group New Group
    ../../../../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc16_ot.a
software components: CMSIS:CORE 5.2.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
